# Keil uVision project Apollo3Loramac.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.2
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Apollo3Loramac
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=3
  c define: HW_ECOVETTE AM_PACKAGE_BGA AM_PART_APOLLO3 SOFT_SE REGION_EU868 ACTIVE_REGION=LORAMAC_REGION_EU868
  c include: ..\AmbiqSuite_R3.1.1\utils;..\AmbiqSuite_R3.1.1\mcu\apollo3;..\AmbiqSuite_R3.1.1\CMSIS\AmbiqMicro\Include;..\lora_library;..\lora_library\boards\Apollo3_V2;..\lora_library\system;..\lora_library\radio;..\lora_library\peripherals;..\lora_library\peripherals\soft-se;..\lora_library\mac;..\lora_library\mac\region;..\lora_library\apps\LoRaMac\common;..\lora_library\apps\LoRaMac\common\LmHandler;..\lora_library\apps\LoRaMac\common\LmHandler\packages;..\apollo3_loramac;..\library;..\lora_library\boards
  memory RVCT4: ROM 0xc000 size 0xf4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  group Source Group 1
    ./: main.c
  group lib
    ../AmbiqSuite_R3.1.1/mcu/apollo3/hal/: am_hal_adc.c am_hal_ble.c am_hal_ble_patch.c am_hal_ble_patch_b0.c am_hal_burst.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_cmdq.c am_hal_ctimer.c am_hal_debug.c am_hal_entropy.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_mspi.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_scard.c am_hal_secure_ota.c am_hal_security.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_wdt.c
  group hardware Lib
    ../library/: am1805.h as7341.h dac63002.h device.h gpio.h i2c.h ina232.h mb85rc64ta.h PamMeasurements.h pins.h sensirion_common.h sensirion_config.h sensirion_i2c.h sensirion_i2c_hal.h sht4.h sht4x_i2c.h shtc3.h spi.h taskHandler.h timing.h
    ./: fuota.h periodicUplink.h
  group hardware Library
    ../library/: am1805.c as7341.c dac63002.c device.c gpio.c i2c.c ina232.c mb85rc64ta.c PamMeasurements.c sensirion_common.c sensirion_i2c.c sensirion_i2c_hal.c sht4.c sht4x_i2c.c shtc3.c spi.c taskhandler.c timing.c
    ./: fuota.c periodicUplink.c
  group util
    ../AmbiqSuite_R3.1.1/utils/: am_util_ble.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_regdump.c am_util_stdio.c am_util_string.c am_util_time.c
  group mac
    ../lora_library/mac/: LoRaMac.c LoRaMac.h LoRaMacAdr.c LoRaMacAdr.h LoRaMacClassB.c LoRaMacClassB.h LoRaMacClassBConfig.h LoRaMacClassBNvm.h LoRaMacCommands.c LoRaMacCommands.h LoRaMacConfirmQueue.c LoRaMacConfirmQueue.h LoRaMacCrypto.c LoRaMacCrypto.h LoRaMacCryptoNvm.h LoRaMacHeaderTypes.h LoRaMacMessageTypes.h LoRaMacParser.c LoRaMacParser.h LoRaMacSerializer.c LoRaMacSerializer.h LoRaMacTest.h LoRaMacTypes.h secure-element.h secure-element-nvm.h
  group region
    ../lora_library/mac/region/: Region.c Region.h RegionCommon.c RegionCommon.h RegionEU433.c RegionEU433.h RegionEU868.c RegionEU868.h RegionNvm.h
  group peripherals
    ../lora_library/peripherals/soft-se/: aes.c aes.h cmac.c cmac.h se-identity.h soft-se.c soft-se-hal.c soft-se-hal.h
  group radio
    ../lora_library/radio/: radio.c radio.h sx126x.c sx126x.h
  group system
    ../lora_library/system/: delay.c delay.h nvmm.c nvmm.h systime.c systime.h timer.c timer.h uart.c uart.h
  group LoRaMac
    ../lora_library/apps/LoRaMac/common/LmHandler/packages/: FragDecoder.c FragDecoder.h LmhPackage.h LmhpClockSync.c LmhpClockSync.h LmhpCompliance.c LmhpCompliance.h LmhpFragmentation.c LmhpFragmentation.h LmhpRemoteMcastSetup.c LmhpRemoteMcastSetup.h
    ../lora_library/apps/LoRaMac/common/: cli.c CayenneLpp.c CayenneLpp.h cli.h Commissioning.h githubVersion.h LmHandlerMsgDisplay.c LmHandlerMsgDisplay.h NvmDataMgmt.c NvmDataMgmt.h
    ../lora_library/apps/LoRaMac/common/LmHandler/: LmHandler.c LmHandler.h LmHandlerTypes.h
    ./: JalapenosLpp.c JalapenosLpp.h
  group Apollo3
    ../lora_library/boards/Apollo3_V2/: board.c eeprom-board.c gpio-board.c pinName-board.c pinName-ioe.c spi-board.c sx126x-board.c transmitConfig.h utilities.c rtc-board.c
    ../lora_library/boards/: board.h eeprom-board.h gpio-board.h pinName-board.h pinName-ioe.h rtc-board.h spi-board.h sx126x-board.h utilities.h
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, Device:Startup 1.4.1
